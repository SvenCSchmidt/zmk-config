## boards/shields/le_oeuf/Kconfig.defconfig
```kconfig
if SHIELD_LE_OEUF

config ZMK_KEYBOARD_NAME
    default "Onyx Cinder"

config SPI
    default y

endif
```
